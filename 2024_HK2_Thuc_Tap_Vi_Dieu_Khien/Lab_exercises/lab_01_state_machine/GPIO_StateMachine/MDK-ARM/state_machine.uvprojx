# Keil uVision project state_machine.uvprojx, settings and files
target state_machine (6190000::V6.19::ARMCLANG)
  device: STM32F207VCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: BT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F207xx
  c include: ../Core/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Drivers/CMSIS/Include;../MDK-ARM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User/Core
    ./: myLCD.c myGPIO.c myLED.c
    ../Core/Src/: main.c stm32f2xx_it.c stm32f2xx_hal_msp.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
software components: CMSIS:CORE 5.6.0
